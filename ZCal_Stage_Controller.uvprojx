# Keil uVision project ZCal_Stage_Controller.uvprojx, settings and files
target ZCal_Stage_Controller (6070000::V6.7::.\ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: ZCal_Stage_Controller
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=7
  c define: MBED_BUILD_TIMESTAMP=1618489056.7654994 DEVICE_WATCHDOG=1 __ASSERT_MSG MBED_MINIMAL_PRINTF __MBED__=1 TARGET_RELEASE DEVICE_MPU=1 TOOLCHAIN_ARM_STD __MBED_CMSIS_RTOS_CM DEVICE_CAN=1 DEVICE_USTICKER=1 TARGET_CORTEX_M TOOLCHAIN_ARM DEVICE_SLEEP=1 DEVICE_PORTINOUT=1 USE_HAL_DRIVER DEVICE_SERIAL_ASYNCH=1 DEVICE_SERIAL=1 TARGET_RTOS_M4_M7 DEVICE_PORTOUT=1 DEVICE_STDIO_MESSAGES=1 TARGET_LIKE_MBED DEVICE_RESET_REASON=1 DEVICE_FLASH=1 MBED_ROM_START=0x8000000 TARGET_M4 DEVICE_ANALOGOUT=1 MULADDC_CANNOT_USE_R7 USE_FULL_LL_DRIVER TARGET_CORTEX TARGET_NAME=NUCLEO_F446RE DEVICE_SPI_ASYNCH=1 TARGET_MCU_STM32 TARGET_STM32F446xE ARM_MATH_CM4 TOOLCHAIN_ARMC6 DEVICE_PWMOUT=1 DEVICE_PORTIN=1 MBED_ROM_SIZE=0x80000 DEVICE_SPI=1 DEVICE_I2C_ASYNCH=1 TARGET_STM TARGET_NUCLEO_F446RE MBED_RAM_SIZE=0x20000 __CMSIS_RTOS MBED_TRAP_ERRORS_ENABLED=1 __CORTEX_M4 DEVICE_RTC=1 DEVICE_INTERRUPTIN=1 DEVICE_LPTICKER=1 DEVICE_ANALOGIN=1 DEVICE_SERIAL_FC=1 DEVICE_SPISLAVE=1 STM32F446xx TARGET_FF_ARDUINO __FPU_PRESENT=1 TARGET_STM32F4 MBED_RAM_START=0x20000000 TRANSACTION_QUEUE_SIZE_SPI=2 TARGET_FF_MORPHO DEVICE_I2C=1 TARGET_LIKE_CORTEX_M4 DEVICE_I2CSLAVE=1
  c misc: -fno-c++-static-destructors -fdata-sections -fshort-wchar --target=arm-arm-none-eabi -c -Wno-reserved-user-defined-literal -mcpu=cortex-m4 -Wno-armcc-pragma-push-pop -Wno-armcc-pragma-anon-unions -Wno-deprecated-register -mfpu=fpv4-sp-d16 -fno-rtti -mthumb -fno-exceptions -mfloat-abi=hard -fshort-enums -include mbed_config.h
  c include: ;/usr/src/mbed-sdk;X_NUCLEO_IHM01A1;X_NUCLEO_IHM01A1/Components;X_NUCLEO_IHM01A1/Components/Common;X_NUCLEO_IHM01A1/Components/L6474;X_NUCLEO_IHM01A1/ST_INTERFACES;X_NUCLEO_IHM01A1/ST_INTERFACES/Actuators;X_NUCLEO_IHM01A1/ST_INTERFACES/Common;X_NUCLEO_IHM01A1/ST_INTERFACES/Communications;X_NUCLEO_IHM01A1/ST_INTERFACES/Sensors;X_NUCLEO_IHM01A1/X_NUCLEO_COMMON;X_NUCLEO_IHM01A1/X_NUCLEO_COMMON/DbgMCU;X_NUCLEO_IHM01A1/X_NUCLEO_COMMON/DevI2C;X_NUCLEO_IHM01A1/X_NUCLEO_COMMON/DevSPI;mbed;mbed/TARGET_NUCLEO_F446RE;mbed/TARGET_NUCLEO_F446RE/TARGET_STM;mbed/TARGET_NUCLEO_F446RE/TARGET_STM/TARGET_STM32F4;mbed/TARGET_NUCLEO_F446RE/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F446RE;mbed/TARGET_NUCLEO_F446RE/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F446RE/device;mbed/TARGET_NUCLEO_F446RE/TARGET_STM/TARGET_STM32F4/device;mbed/drivers;mbed/hal;mbed/platform
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__MBED_CMSIS_RTOS_CM,-DTRANSACTION_QUEUE_SIZE_SPI=2,-D__FPU_PRESENT=1,-DARM_MATH_CM4,-D__CORTEX_M4,-DUSE_FULL_LL_DRIVER,-DUSE_HAL_DRIVER,-D__CMSIS_RTOS,-DSTM32F446xx
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_NUCLEO_F446RE/TOOLCHAIN_ARM_STD/stm32f446xx.sct
  link misc: --keep=os_cb_sections --any_contingency --predefine="-DMBED_ROM_SIZE=0x80000" --cpu=Cortex-M4 --predefine="-DMBED_RAM_SIZE=0x20000" --predefine="-DMBED_BOOT_STACK_SIZE=4096" --predefine="-DXIP_ENABLE=0" --show_full_path --predefine="-DMBED_ROM_START=0x8000000" --predefine="-DMBED_RAM_START=0x20000000" --inline --legacyalign
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h Serial.h SerialBase.h SPI.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h Driver_Common.h Driver_Storage.h emac_api.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_NUCLEO_F446RE/TOOLCHAIN_ARM_STD/: analogin_api.o analogout_api.o can_api.o cmsis_nvic.o gpio_api.o gpio_irq_api.o hal_tick.o i2c_api.o lp_ticker.o mbed.ar mbed_board.o mbed_overrides.o PeripheralPins.o pinmap.o port_api.o pwmout_api.o retarget.o rtc_api.o serial_api.o sleep.o spi_api.o startup_stm32f446xx.o stm32f4xx_hal.o stm32f4xx_hal_adc.o stm32f4xx_hal_adc_ex.o stm32f4xx_hal_can.o stm32f4xx_hal_cec.o stm32f4xx_hal_cortex.o stm32f4xx_hal_crc.o stm32f4xx_hal_cryp.o stm32f4xx_hal_cryp_ex.o stm32f4xx_hal_dac.o stm32f4xx_hal_dac_ex.o stm32f4xx_hal_dcmi.o stm32f4xx_hal_dcmi_ex.o stm32f4xx_hal_dfsdm.o stm32f4xx_hal_dma.o stm32f4xx_hal_dma2d.o stm32f4xx_hal_dma_ex.o stm32f4xx_hal_dsi.o stm32f4xx_hal_eth.o stm32f4xx_hal_flash.o stm32f4xx_hal_flash_ex.o stm32f4xx_hal_flash_ramfunc.o stm32f4xx_hal_fmpi2c.o stm32f4xx_hal_fmpi2c_ex.o stm32f4xx_hal_gpio.o stm32f4xx_hal_hash.o stm32f4xx_hal_hash_ex.o stm32f4xx_hal_hcd.o stm32f4xx_hal_i2c.o stm32f4xx_hal_i2c_ex.o stm32f4xx_hal_i2s.o stm32f4xx_hal_i2s_ex.o stm32f4xx_hal_irda.o stm32f4xx_hal_iwdg.o stm32f4xx_hal_lptim.o stm32f4xx_hal_ltdc.o stm32f4xx_hal_ltdc_ex.o stm32f4xx_hal_msp_template.o stm32f4xx_hal_nand.o stm32f4xx_hal_nor.o stm32f4xx_hal_pccard.o stm32f4xx_hal_pcd.o stm32f4xx_hal_pcd_ex.o stm32f4xx_hal_pwr.o stm32f4xx_hal_pwr_ex.o stm32f4xx_hal_qspi.o stm32f4xx_hal_rcc.o stm32f4xx_hal_rcc_ex.o stm32f4xx_hal_rng.o stm32f4xx_hal_rtc.o stm32f4xx_hal_rtc_ex.o stm32f4xx_hal_sai.o stm32f4xx_hal_sai_ex.o stm32f4xx_hal_sd.o stm32f4xx_hal_sdram.o stm32f4xx_hal_smartcard.o stm32f4xx_hal_spdifrx.o stm32f4xx_hal_spi.o stm32f4xx_hal_sram.o stm32f4xx_hal_tim.o stm32f4xx_hal_tim_ex.o stm32f4xx_hal_uart.o stm32f4xx_hal_usart.o stm32f4xx_hal_wwdg.o stm32f4xx_ll_fmc.o stm32f4xx_ll_fsmc.o stm32f4xx_ll_sdmmc.o stm32f4xx_ll_usb.o stm_spi_api.o sys.o system_stm32f4xx.o trng_api.o us_ticker.o
    mbed/TARGET_NUCLEO_F446RE/: arm_common_tables.h arm_const_structs.h arm_math.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h
    mbed/platform/: Callback.h CallChain.h CircularBuffer.h critical.h CThunk.h FunctionPointer.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_stats.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h toolchain.h Transaction.h wait_api.h
    mbed/TARGET_NUCLEO_F446RE/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F446RE/device/: cmsis.h cmsis_nvic.h hal_tick.h stm32f446xx.h stm32f4xx.h stm32f4xx_hal_conf.h system_stm32f4xx.h
    mbed/TARGET_NUCLEO_F446RE/TARGET_STM/TARGET_STM32F4/: common_objects.h device.h gpio_object.h PeripheralPins.h rtc_api_hal.h
    mbed/: mbed.h
    mbed/TARGET_NUCLEO_F446RE/TARGET_STM/: mbed_rtx.h
    mbed/TARGET_NUCLEO_F446RE/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F446RE/: objects.h PeripheralNames.h PinNames.h PortNames.h
    mbed/TARGET_NUCLEO_F446RE/TARGET_STM/TARGET_STM32F4/device/: stm32_hal_legacy.h stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_can.h stm32f4xx_hal_cec.h stm32f4xx_hal_conf_template.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_cryp.h stm32f4xx_hal_cryp_ex.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dcmi.h stm32f4xx_hal_dcmi_ex.h stm32f4xx_hal_def.h stm32f4xx_hal_dfsdm.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_dsi.h stm32f4xx_hal_eth.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_fmpi2c.h stm32f4xx_hal_fmpi2c_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hash.h stm32f4xx_hal_hash_ex.h stm32f4xx_hal_hcd.h stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_irda.h stm32f4xx_hal_iwdg.h stm32f4xx_hal_lptim.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_ltdc_ex.h stm32f4xx_hal_nand.h stm32f4xx_hal_nor.h stm32f4xx_hal_pccard.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_qspi.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rng.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_sai.h stm32f4xx_hal_sai_ex.h stm32f4xx_hal_sd.h stm32f4xx_hal_sdram.h stm32f4xx_hal_smartcard.h stm32f4xx_hal_spdifrx.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_hal_usart.h stm32f4xx_hal_wwdg.h stm32f4xx_ll_fmc.h stm32f4xx_ll_fsmc.h stm32f4xx_ll_sdmmc.h stm32f4xx_ll_usb.h
  group X_NUCLEO_IHM01A1
    X_NUCLEO_IHM01A1/ST_INTERFACES/Actuators/: BDCMotor.h StepperMotor.h
    X_NUCLEO_IHM01A1/ST_INTERFACES/Common/: Component.h
    X_NUCLEO_IHM01A1/Components/Common/: component_def.h motor_def.h
    X_NUCLEO_IHM01A1/X_NUCLEO_COMMON/DbgMCU/: DbgMCU.h
    X_NUCLEO_IHM01A1/X_NUCLEO_COMMON/DevI2C/: DevI2C.h
    X_NUCLEO_IHM01A1/X_NUCLEO_COMMON/DevSPI/: DevSPI.h
    X_NUCLEO_IHM01A1/ST_INTERFACES/Sensors/: GyroSensor.h HumiditySensor.h LightSensor.h MagneticSensor.h MotionSensor.h PressureSensor.h RangeSensor.h TempSensor.h
    X_NUCLEO_IHM01A1/Components/L6474/: L6474.cpp L6474.h L6474_config.h L6474_def.h
    X_NUCLEO_IHM01A1/ST_INTERFACES/Communications/: Nfc.h
    X_NUCLEO_IHM01A1/: QEI.cpp QEI.h
  group ZCal_Stage_Controller
    ./: main.cpp mbed_config.h
